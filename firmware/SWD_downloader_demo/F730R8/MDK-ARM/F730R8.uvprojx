# Keil uVision project F730R8.uvprojx, settings and files
target F730R8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F730R8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: F730R8 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F730xx
  c include: ../Inc;    ../Drivers/STM32F7xx_HAL_Driver/Inc;    ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;    ../Drivers/CMSIS/Include;    ..\dap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f730xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c spi.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group DAP
    ../dap/: DAP.c error.c JTAG_DP.c STM32F10x_128.c SW_DP.c SWD_flash.c SWD_host.c SWO.c
software components: CMSIS:CORE 4.3.0
