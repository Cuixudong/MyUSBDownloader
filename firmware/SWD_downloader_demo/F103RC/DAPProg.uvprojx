# Keil uVision project DAPProg.uvprojx, settings and files
target STM32F103C8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DAPProg +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\src\DAP;.\src\CSL;.\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\STM32F10x_StdPeriph_Driver;.\src\CSL\STM32_USB-FS-Device_Driver;.\doc\FlashAlgo;.\src\algo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./src/: main.c error.c SWD_host.c SWD_flash.c
    ./src/algo/: STM32F10x_128.c
  group DAP
    ./src/DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group CSL/CMSIS
    ./src/CSL/CMSIS/DeviceSupport/: system_stm32f10x.c
    ./src/CSL/CMSIS/DeviceSupport/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group CSL/StdPD
    ./src/CSL/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
target STM32F103RC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DAPProg +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\src\DAP;.\src\CSL;.\src\CSL\CMSIS\CoreSupport;.\src\CSL\CMSIS\DeviceSupport;.\src\CSL\STM32F10x_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
